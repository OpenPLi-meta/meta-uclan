KV = "4.4.35"
SRCDATE = "20240306"

SRC_URI = "file://ustym4kpro-hiko-20240306.zip"

require uclan-dvb-modules-hisi.inc
